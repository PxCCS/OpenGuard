RDEPENDS_${PN} += "python3-misc"
