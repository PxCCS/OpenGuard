RDEPENDS_${PN}_remove = "bash"
