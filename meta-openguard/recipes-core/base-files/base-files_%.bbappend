# set hostname unconditionally to openguard
hostname = "openguard"

