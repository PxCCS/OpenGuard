FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-rm-many-system-users.patch \
            file://0002-rm-many-system-groups.patch \
           "
