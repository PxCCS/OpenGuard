GROUPADD_PARAM_${PN}_remove = "-r netdev"
