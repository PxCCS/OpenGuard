DESCRIPTION = "Python ptyprocess"
LICENSE = "ISC"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=185d8e18ea014d72f7912c656443bd3d"

SRC_URI[md5sum] = "d3b8febae1b8c53b054bd818d0bb8665"

PYPI_PACKAGE = "ptyprocess"

inherit pypi setuptools3
