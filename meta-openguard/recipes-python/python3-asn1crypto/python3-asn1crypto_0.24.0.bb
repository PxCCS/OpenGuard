inherit setuptools3
require python-asn1crypto.inc

RDEPENDS_${PN}_class-target += " \
    python3-shell \
"
