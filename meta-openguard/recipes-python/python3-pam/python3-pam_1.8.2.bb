DESCRIPTION = "Python PAM module using ctypes, py3/py2."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=64326d42471b493c5c088305364ad5da"

SRC_URI[md5sum] = "db71b6b999246fb05d78ecfbe166629d"

PYPI_PACKAGE = "python-pam"

inherit pypi setuptools3
